Commit message: Update (Unsaved).xacro

File: line/urdf/(Unsaved).xacro (robot description, xacro)
@@ -114,5 +114,5 @@
   <parent link="base_link"/>
   <child link="rightwheel_1"/>
-  <axis xyz="0.0 0.0 -1.0"/>
+  <axis xyz="0.0 0.0 1.0"/>
 </joint>
 <joint name="Rigid3" type="fixed">
